## tests/app_logic/testcase.yaml
```yaml
tests:
  app_logic.unit:
    platform_allow: nrf7002dk/nrf5340/cpuapp
    tags: app_logic
    harness: ztest
```
